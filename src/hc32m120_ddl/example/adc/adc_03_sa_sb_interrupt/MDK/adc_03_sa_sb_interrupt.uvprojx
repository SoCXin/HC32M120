# Keil uVision project adc_03_sa_sb_interrupt.uvprojx, settings and files
target adc_03_sa_sb_interrupt_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32M120J6TB HDSC
  pack: HDSC.HC32M120.1.0.6
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: adc_03_sa_sb_interrupt
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32M120,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32m120.s
    ../../../../mcu/common/: system_hc32m120.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32m120_clk.c hc32m120_utility.c hc32m120_interrupts.c hc32m120_gpio.c hc32m120_adc.c hc32m120_icg.c
  group Readme
    ../: Readme.txt
target adc_03_sa_sb_interrupt_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M120J6TB HDSC
  pack: HDSC.HC32M120.1.0.6
  cpu: as above
  output: adc_03_sa_sb_interrupt +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32M120,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
