# IAR project HC32M140FX.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32m140fx.srec
  ILINK.IlinkOutputFile: hc32m140fx.out
  ILINK.IlinkIcfFile: config\HC32M14XX8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  group common
    ../../common/: system_hc32m140fx.c
    ./: startup_hc32m140fx.s
  group source
    ../source/: main.c
