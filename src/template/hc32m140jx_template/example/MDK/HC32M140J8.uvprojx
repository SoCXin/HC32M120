# Keil uVision project HC32M140J8.uvprojx, settings and files
target HC32M140JX_Release (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32M140JX
  c flags: Optim=1
  c include: ..\..\common;..\source
  memory RVCT4: ROM 0x00000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group common
    ./: startup_hc32m140jx.s
    ../../common/: system_hc32m140jx.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 4.1.0
