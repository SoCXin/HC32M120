# IAR project HC32F146KX.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f146kx.srec
  ILINK.IlinkOutputFile: hc32f146kx.out
  ILINK.IlinkIcfFile: config\HC32F14XXA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  group common
    ../../common/: system_hc32f146kx.c
    ./: startup_hc32f146kx.s
  group source
    ../source/: main.c
