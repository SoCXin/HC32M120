# Keil uVision project HC32M120F6TB.uvprojx, settings and files
target HC32M120F6TB_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32M120F6TB HDSC
  pack: HDSC.HC32M120.1.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(20000000) ESEL ELITTLE
  output: HC32M120F6TB
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HC32M120
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32m120f6tb.s
    ../../common/: system_hc32m120f6tb.c
  group source
    ../source/: main.c
target HC32M120F6TB_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32M120F6TB HDSC
  pack: HDSC.HC32M120.1.0.0
  cpu: as above
  output: HC32M120F6TB +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32M120
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
