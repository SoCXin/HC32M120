# IAR project HC32M120J6TB.ewp, settings and files
configuration debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: HC32M120; __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32m120j6tb.srec
  ILINK.IlinkOutputFile: hc32m120j6tb.out
  ILINK.IlinkIcfFile: config\HC32M120.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32M120
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group common
    ../../common/: system_hc32m120j6tb.c
    ./: startup_hc32m120j6tb.s
  group source
    ../source/: main.c
